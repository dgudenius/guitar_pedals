.title KiCad schematic
R1 Net-_C1-Pad2_ In 39k
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ .1u
R2 Net-_C2-Pad1_ Net-_C1-Pad1_ 470k
C2 Net-_C2-Pad1_ Net-_C1-Pad1_ 470p
Q1 Net-_C2-Pad1_ Net-_C1-Pad1_ Net-_Q1-Pad3_ BC337
R3 Net-_C1-Pad1_ GND 100k
R4 Net-_Q1-Pad3_ GND 390
C3 Net-_C3-Pad1_ Net-_C2-Pad1_ .1u
Sustain1 Net-_C3-Pad1_ Net-_C4-Pad2_ Net-_R6-Pad1_ A50k
R6 Net-_R6-Pad1_ GND 1k
C4 Net-_C4-Pad1_ Net-_C4-Pad2_ .1u
R7 Net-_C5-Pad2_ Net-_C4-Pad1_ 10k
R9 Net-_C5-Pad2_ GND 100k
C5 Net-_C5-Pad1_ Net-_C5-Pad2_ .047u
R8 Net-_C6-Pad1_ Net-_C5-Pad2_ 470k
D2 Net-_C5-Pad1_ Net-_C6-Pad1_ 1N914
Q2 Net-_C6-Pad1_ Net-_C5-Pad2_ Net-_Q2-Pad3_ BC549
R10 Net-_Q2-Pad3_ GND 390
C7 Net-_C7-Pad1_ Net-_C6-Pad1_ .1u
R12 Net-_C8-Pad2_ Net-_C7-Pad1_ 10k
R14 Net-_C8-Pad2_ GND 100k
C8 Net-_C8-Pad1_ Net-_C8-Pad2_ .047u
R13 Net-_Bypass1-Pad1_ Net-_C8-Pad2_ 470K
D3 Net-_Bypass1-Pad1_ Net-_C8-Pad1_ 1N914
D4 Net-_C8-Pad1_ Net-_Bypass1-Pad1_ 1N914
Q3 Net-_Bypass1-Pad1_ Net-_C8-Pad2_ Net-_Q3-Pad3_ BC549
R15 Net-_Q3-Pad3_ GND 390
R11 V+ Net-_C6-Pad1_ 10k
D1 Net-_C6-Pad1_ Net-_C5-Pad1_ 1n914
R16 V+ Net-_Bypass1-Pad1_ 10k
R5 V+ Net-_C2-Pad1_ 10k
C11 Net-_C11-Pad1_ GND .01u
C10 Net-_C10-Pad1_ Net-_Bypass1-Pad1_ .0047u
R18 GND Net-_C10-Pad1_ 22k
R17 Net-_C11-Pad1_ Net-_Bypass1-Pad1_ 39k
Tone1 Net-_C10-Pad1_ Net-_Bypass1-Pad3_ Net-_C11-Pad1_ B100k
Bypass1 Net-_Bypass1-Pad1_ Net-_Bypass1-Pad1_ Net-_Bypass1-Pad3_ A250k
C12 Net-_C12-Pad1_ Net-_Bypass1-Pad3_ .1u
R20 Net-_C12-Pad1_ GND 100k
R19 Net-_C13-Pad2_ Net-_C12-Pad1_ 470k
R22 V+ Net-_C13-Pad2_ 10k
Q4 Net-_C13-Pad2_ Net-_C12-Pad1_ Net-_Q4-Pad3_ BC547
C13 Net-_C13-Pad1_ Net-_C13-Pad2_ .1u
C14 NC_01 Net-_C14-Pad2_ 1u
Volume1 Net-_C13-Pad1_ Net-_C14-Pad2_ GND A100k
R21 Net-_Q4-Pad3_ GND 2.2K
C6 Net-_C6-Pad1_ Net-_C5-Pad2_ 470p
C9 Net-_Bypass1-Pad1_ Net-_C8-Pad2_ 470p
R23 In GND 1.2Meg
.end
